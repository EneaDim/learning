# Keil uVision project blinky.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: blinky
  AfterMake: $K\ARM\ARMCC\BIN\fromelf --vhx --8x4 #L --output itcm
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup code
    ./: startup_cm3_mcu.s system_cm3_mcu.c
  group Application
    ./: main.c LED.c uart_util.c
software components: CMSIS:CORE 5.2.0, Compiler:I/O:STDOUT 1.2.0
